# Keil uVision project Clock.uvproj, settings and files
target release (MCS-51)
  device: STC89C516RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(45000000) MODP2
  output: Clock +hex
  c flags: Optimize=9
  c define: __OSCILLATO_6T__
  group common
    ./: sm.c main.c STARTUP.A51 com.c rtc.c i2c.c key.c task.c led.c alarm.c power.c misc.c mod_common.c beeper.c clock.c timer.c int_hub.c fuse.c hg.c lt_timer.c serial_hub.c thermo.c rom.c delay_task.c shell.c debug.c mpu.c indicator.c remote.c radio.c
  group clock
    ./: sm_clock_timer.c sm_clock_counter.c sm_clock_display.c sm_clock_powersave.c sm_clock_mod_alarm.c sm_clock_alarm.c sm_clock_mod_time.c
  group power_pack
    ./: sm_power_pack_display.c sm_power_pack_powersave.c
  group radio
    ./: sm_radio_display.c sm_radio_powersave.c sm_radio_mod.c
  group fuse
    ./: sm_fuse_test.c sm_fuse_param.c sm_fuse_timer.c sm_fuse_detonate.c sm_fuse_powersave.c
  group global_flag
    ./: sm_global_flag_mod.c
  group shell
    ./: cmd_help.c cmd_serial.c cmd_int.c cmd_i2c.c cmd_dbg.c cmd_reboot.c cmd_task.c cmd_sm.c cmd_beeper.c cmd_thermo.c cmd_mpu.c cmd_rtc.c cmd_power.c cmd_radio.c
target debug (MCS-51)
  device: STC89C516RD+ STC
  cpu: as above
  output: Clock_debug +hex
  c flags: Optimize=9
  c define: __OSCILLATO_6T__,__CLOCK_DEBUG__
