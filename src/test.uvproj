# Keil uVision project test.uvproj, settings and files
target default (MCS-51)
  device: STC89C516RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: com.c i2c.c test.c
