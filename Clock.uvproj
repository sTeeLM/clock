# Keil uVision project Clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: Clock +hex
  c flags: Optimize=8
  group Source Group 1
    ./: STARTUP.A51 main.c com.c timer.c rtc.c i2c.c key.c task.c led.c alarm.c power.c misc.c sm_display.c counter.c sm_mod_time.c sm_mod_alarm.c sm_mod_global_flag.c sm_pac_hit.c sm_counter.c sm_timer.c sm.c mod_common.c
